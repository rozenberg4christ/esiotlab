# Keil uVision project Emb C.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: Emb C
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: timer2.c STARTUP.A51 timer1.c serial1.c serial2.c
